V1 1 0 12.0
R1 1 2 1000.0
R2 2 3 2000.0
R3 2 4 2000.0
R4 3 4 1500.0
R5 3 0 1100.0
R6 4 0 950.0
